# Keil uVision project pump.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: pump +hex
  c flags: Optim=1 OneElfS=1
  c include: ..\SRC\INC\LIB_INC;..\SRC\INC\OS_INC;..\SRC\BSP;..\SRC\SYSTEM;..\SRC\UNIT\LCD320240
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group SYSTEM
    ../src/system/: communication.c flash.c interface.c main.c pump_system.h
    ../src/bsp/: stm32f10x_it.c
  group LIB
    ../src/lib/: stm32lib35.lib stm32ucoslib.lib
  group BSP
    ../src/bsp/: stm32f10x_conf.h startup_stm32f10x_hd.s system_stm32f10x.c gpio.c nvic.c pwm.c tim.c usart.c rcc.c ad.c
  group UNIT
    ../src/unit/pressure/: pressure.c
    ../src/unit/lcd12864/: lcd12864.c
    ../src/unit/pumpcontrol/: pump.c
    ../src/unit/flowsetting/: flow.c
    ../src/unit/protocol/: modbus_rtu_slave.c
  group Algorithm
    ../src/algorithm/: fft.c pid.c

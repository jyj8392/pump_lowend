# Keil uVision project TBP1002D.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C5131 Microchip
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x7FFF) CLOCK(32000000) MODP2
  output: TBP1002D +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: MAIN.c STC_ISP_RW.c lcd.c pump_AtoB.c TLC549.asm DELAY_NS.asm KEY_SCAN.asm KEY_SCAN_ONE.asm OUTPUT.asm
